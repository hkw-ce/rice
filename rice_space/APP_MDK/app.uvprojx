# Keil uVision project app.uvprojx, settings and files
target app (6190000::V6.19::ARMCLANG)
  device: MM32F0273D7P MindMotion
  pack: MindMotion.MM32F0270_DFP.0.1.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: USE_APP
  c include: ..\base\lib\MM32F027x\HAL_Lib\Inc;..\base\lib\MM32F027x\Include;..\base\plat;..\3rd\ulog;..\3rd\MultiButton;..\base\core;..\base\rtthread-nano-4.1.1\rt-thread\include;..\base\rtthread-nano-4.1.1\rt-thread\components\finsh;..\base\rtthread-nano-4.1.1\rt-thread\bsp\_template;..\base\rtthread-nano-4.1.1\rt-thread\libcpu\arm\cortex-m0;..\base\dev\VL6180;..\base\lib\CMSIS\KEIL_Core;..\3rd\VL53L0X;..\3rd\VL53L0X\platform\inc;..\3rd\VL53L0X\core\inc;..\base\dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group core
    ../base/core/: main.c app.c ih_control.c
  group task
    ../base/core/: base_task.c
  group plat
    ../base/plat/: mm32_adc.c mm32_gpio.c mm32_pwm.c mm32_soft_i2c_v1.c mm32_uart.c mm32f0270_it.c platform.c
  group dev
    ../base/dev/: gn1650.c hx711.c ina226.c key.c onewire_bus.c PWM.c SC7A20.c NTC.c
  group HAL_LIB
    ../base/lib/MM32F027x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group START_UP
    ../base/lib/MM32F027x/Source/: system_mm32f0270.c
    ../base/lib/MM32F027x/Source/KEIL_StartAsm/: startup_mm32f0270_keil.s
  group rtthread/src
    ../base/rtthread-nano-4.1.1/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rrthread/port
    ../base/rtthread-nano-4.1.1/rt-thread/libcpu/arm/cortex-m0/: context_gcc.S cpuport.c
  group rrthread/board
    ../base/rtthread-nano-4.1.1/rt-thread/bsp/_template/: board.c
  group rtthread/finish
    ../base/rtthread-nano-4.1.1/rt-thread/components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group ulog
    ../3rd/ulog/: ulog.c
    ../3rd/ulog/backend/: console_be.c
  group 3rd
    ../3rd/MultiButton/: multi_button.c
  group VL53L0X
    ../3rd/VL53L0X/: bsp_VL53L0X.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_it.c
    ../3rd/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ../3rd/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
